# Keil uVision project usb_mass_disk.uvprojx, settings and files
target pro_device_mass (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usb_mass_disk +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu
  c include: ..\app;..\board_dev;..\board_dev\lcd;..\fatfs;..\fatfs\src;..\hardware;..\libc;..\project;..\stm32f4xx_core;..\stm32f4xx_fwlib;..\stm32f4xx_fwlib\inc;..\system;..\USB\STM32_USB_OTG_Driver\inc;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_Device_Library\Class\msc\inc;..\USB\USB_device_mas_disk
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x9000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: my_malloc.c my_printf.c share.c
  group libc
    ../libc/: ctype.c stdio.c stdlib.c string.c time.c
  group project
    ./: main.c user_task.c user_tcb_v3.c
  group fatfs
    ../fatfs/src/option/: cc936.c
    ../fatfs/src/: diskio.c ff.c
    ../fatfs/: myfat.c
  group board_dev
    ../board_dev/: led.c sdio_sdcard_v5.c spi_flash_v4.c
    ../board_dev/lcd/: lcd_app_v2.c lcd_drv_fsmc407_v6.c
  group hardware
    ../hardware/: fsmc.c rtc_v2.c sdio_v3.c spi_v3.c uart.c
  group system
    ../system/: cpu_related_v3.c cpu_related_a.asm systick.c
  group stm32f4xx_core
    ../stm32f4xx_core/: startup_stm32f40_41xxx.s
  group stm32f4xx_fwlib
    ../stm32f4xx_fwlib/: stm32f4xx_it.c system_stm32f4xx.c
    ../stm32f4xx_fwlib/src/: misc.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group usb_otg_core
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group usb_device_enum
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group usb_device_mas
    ../USB/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group usb_app_support
    ../USB/USB_device_mas_disk/: usb_app.c usb_bsp.c usb_controller_isr.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
